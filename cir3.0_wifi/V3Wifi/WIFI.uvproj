# Keil uVision project WIFI.uvproj, settings and files
target ConverseUnit (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: WIFI
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A010000)
  AfterMake: fromelf --bin .\CM4\Object\WIFI.axf --output .\CM4\Object\WIFI.bin
  c flags: Optim=1 wLevel=1
  c define: CORE_M4,DEBUG_ETHERNET_UPDATE
  c include: ..\Share\Lpc43xx-CMSIS\Drivers\include;.\uCOS-II\Config\ARM-Cortex-M4;..\Share\UCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\Share\UCOS-II\Source;..\Share\UCOS-II\uC-CPU\ARM-Cortex-M4\RealView;.\CM4\Driver\User;.\CM4\emWin\emWin_header;.\CM4\emWin\emWin_Config;.\CM4\DebugOut;..\Share\Drivers\CCAN;..\Share\Drivers\UART;..\Share\Common;.\CM4\User;..\Share\Drivers\SPIFI_Lib;..\Share\Drivers\Net\keil;..\Share\Drivers\Net\tcp;..\Share\Drivers\Net\udp;..\Share\Drivers\SSP0;..\Share\Drivers\SPIFI;..\Share\Drivers\eMMC;..\ShareG723;..\Share\Protocol;..\CodecGSMR;..\Share\Algorithm;..\Share\Drivers\eeprom;..\Share\DebugOut;..\Share\Drivers\Net;..\Share\Update
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x40000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\CM4\Object\ConverseUnit.sct
  group User
    ./CM4/User/: main.c Task.c TaskStartPrc.c App.c AppMsgDispatchpro.c AppMsgTxpro.c AppMsgRxpro.c MemManage.c AppTime.c LedControl.c AppDefine.c AppNetpro.c AppWifi.c
  group Update
    ./CM4/User/: UpdateApi.c
    ../Share/Update/: UpdataSlave.c update.c
  group Share\LPC43xx-CMSIS
    ../Share/Lpc43xx-CMSIS/Drivers/source/: lpc43xx_cgu.c lpc43xx_scu.c lpc43xx_uart.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_ssp.c lpc43xx_i2s.c lpc43xx_timer.c lpc43xx_rgu.c
  group Share\Driver\Can
    ../Share/Drivers/CCAN/: C_CAN.c ccan_18xx_43xx.c
  group Share\Driver\Spifi
    ../Share/Drivers/SPIFI/: MX66L51235F.c spifilib_dev_common.c spifilib_fam_mac_2b_stat.c
    ../Share/Drivers/SSP0/: SPIFLASH.c
  group Share\Driver\Uart
    ../Share/Drivers/UART/: Uart.c
  group Share\Driver\Net
    ../Share/Drivers/Net/keil/: ETH_LPC43xx.c Net_lib.c TCP_CM3.lib
    ../Share/Drivers/Net/udp/: EthernetUdp.c
    ../Share/Drivers/Net/: EthernetSet.c
  group Share\Algorithm
    ../Share/Algorithm/: crc.c md5.c
  group Share\Common
    ../Share/Common/: version.c CmdDefine.c DataReSend.c DataTransfer.c CanBusControl.c
  group Share\Protocol
    ../Share/Protocol/: ptcir.c ptcan.c
  group Share\uCOS\Ports
    ../Share/UCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Share\uCOS\Source
    ../Share/UCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Share\uCOS\CPU
    ../Share/UCOS-II/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm
  group uCOS\Config
    ./uCOS-II/Config/ARM-Cortex-M4/: app_cfg.h app_hooks.c os_cfg.h
  group Driver\Startup
    ./CM4/Driver/Startup/: startup_LPC43xx.s
  group Driver\System
    ./CM4/Driver/System/: system_LPC43xx.c
  group Driver\User
    ./CM4/Driver/User/: Target.c LED.c GPIO.c UartRxpro.c Net_Config.c CanRxpro.c
  group Share\DebugOut
    ../Share/DebugOut/: DebugOut.c
  group ReadMe
    ./CM4/ReadMe/: 程序修改日志.txt
